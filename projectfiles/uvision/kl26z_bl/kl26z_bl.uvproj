# Keil uVision project kl26z_bl.uvproj, settings and files
target kl26z_bl (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: kl26z_bl +hex
  AfterMake: fromelf --bin $L@L.axf -o $L@L.bin
  c flags: Optim=3 oTime=1 OneElfS=1
  c define: MSC_ENDPOINT, DAPLINK_BL, __RTX, INTERFACE_KL26Z, CPU_MKL26Z128VLH4
  c misc: --gnu --c99
  c include: ..\..\..\source\common\usb; ..\..\..\source\common\usb\msc; ..\..\..\source\common\endpoints\drag-n-drop; ..\..\..\source\daplink_bl; ..\..\..\source\daplink_bl\target; ..\..\..\source\daplink_bl\target\iap_api; ..\..\..\source\common\cmsis-core; ..\..\..\source\common\hal; ..\..\..\source\common\rtos; ..\..\..\source\common\rtos\cm0; ..\..\..\source\daplink_bl\target\iap_api\freescale\driver; ..\..\..\source\daplink_bl\target\iap_api\freescale\devices; ..\..\..\source\daplink_bl\target\iap_api\freescale; ..\..\..\source\daplink_bl\target\iap_api\freescale\devices\MKL26Z4; ..\..\..\source\common\cmsis-core\freescale\kl26z; ..\..\..\source\common\cmsis-core\freescale\kl26z\armcc; ..\..\..\source\common\hal\freescale\kl26z; ..\..\..\source\daplink_bl\target\freescale\kl26z
  asm define: as above
  scatter file: ..\..\..\source\common\cmsis-core\freescale\kl26z\armcc\kl26z_daplink_bl.sct
  group usb_msc
    ../../../source/common/usb/msc/: usbd_core_msc.c usbd_msc.c
    ../../../source/common/endpoints/drag-n-drop/: intelhex.c usbd_user_msc.c virtual_fs.c
  group daplink_bl
    ../../../source/daplink_bl/: daplink.c flash_hal_svc.c main.c RTX_Config.c target_flash.c SVC_Table.s
    ../../../source/common/hal/: config_settings.c validation.c version.c
  group fsl_flash_driver
    ../../../source/daplink_bl/target/iap_api/freescale/: FlashDev.c FlashPrg.c
    ../../../source/daplink_bl/target/iap_api/freescale/driver/: flash_init.c flash_erase.c flash_program.c flash_erase_all.c flash_verify_erase.c flash_get_property.c flash_verify_program.c flash_verify_erase_all.c flash_command_sequence.c
  group rtos
    ../../../source/common/rtos/cm0/: HAL_CM1.c
    ../../../source/common/rtos/: rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
  group target_specific
    ../../../source/daplink_bl/target/freescale/kl26z/: app_config.c
  group host
    ../../../source/daplink_bl/target/iap_api/freescale/driver/: flash_densities_kl_series.c
    ../../../source/common/cmsis-core/freescale/kl26z/: system_MKL26Z4.c
    ../../../source/common/hal/freescale/kl26z/: gpio.c read_uid.c uart.c usbd_MKL26Z4.c usb_config.c
    ../../../source/common/cmsis-core/freescale/kl26z/armcc/: startup_MKL26Z4.s
  group usb_core
    ../../../source/common/usb/: usbd_core.c
