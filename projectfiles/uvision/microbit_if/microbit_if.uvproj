# Keil uVision project microbit_if.uvproj, settings and files
target microbit_if (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: microbit_if +hex
  AfterMake: fromelf --bin $L@L.axf -o $L@L.bin
  c flags: Optim=3 oTime=1 OneElfS=1
  c define: HID_ENDPOINT, MSC_ENDPOINT, CDC_ENDPOINT, DAPLINK_IF, __RTX, INTERFACE_KL26Z, CPU_MKL26Z128VLH4, APP_OFFSET_32K
  c misc: --gnu --c99
  c include: ..\..\..\source\common\usb; ..\..\..\source\common\usb\hid; ..\..\..\source\common\endpoints\cmsis-dap; ..\..\..\source\common\usb\msc; ..\..\..\source\common\endpoints\drag-n-drop; ..\..\..\source\common\usb\cdc; ..\..\..\source\common\endpoints\usb2uart; ..\..\..\source\daplink_if; ..\..\..\source\daplink_if\target; ..\..\..\source\common\cmsis-core; ..\..\..\source\common\hal; ..\..\..\source\common\rtos; ..\..\..\source\common\rtos\cm0; ..\..\..\source\daplink_bl\target\iap_api\freescale\driver; ..\..\..\source\daplink_bl\target\iap_api\freescale\devices\MKL26Z4; ..\..\..\source\common\cmsis-core\freescale\kl26z; ..\..\..\source\common\cmsis-core\freescale\kl26z\armcc; ..\..\..\source\common\hal\freescale\kl26z; ..\..\..\source\daplink_if\target\nordic\nrf51822; ..\..\..\source\overrides
  asm define: as above
  scatter file: ..\..\..\source\common\cmsis-core\freescale\kl26z\armcc\kl26z_daplink_if.sct
  group usb_msc
    ../../../source/common/usb/msc/: usbd_core_msc.c usbd_msc.c
    ../../../source/common/endpoints/drag-n-drop/: intelhex.c usbd_user_msc.c virtual_fs.c
  group microbit
    ../../../source/overrides/: microbit.c
  group usb_cdc
    ../../../source/common/usb/cdc/: usbd_cdc_acm.c usbd_core_cdc.c
    ../../../source/common/endpoints/usb2uart/: serial.c usbd_user_cdc_acm.c
  group rtos
    ../../../source/common/rtos/cm0/: HAL_CM1.c
    ../../../source/common/rtos/: rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
  group daplink_if
    ../../../source/daplink_if/: daplink.c main.c RTX_Config.c swd_host.c target_flash.c SVC_Table.s
    ../../../source/common/hal/: config_settings.c validation.c version.c
  group usb_hid
    ../../../source/common/usb/hid/: usbd_core_hid.c usbd_hid.c
    ../../../source/common/endpoints/cmsis-dap/: DAP.c dap_vendor_command.c JTAG_DP.c SW_DP.c usbd_user_hid.c
  group target_specific
    ../../../source/daplink_if/target/nordic/nrf51822/: app_config.c target_reset.c
  group host
    ../../../source/daplink_bl/target/iap_api/freescale/driver/: flash_densities_kl_series.c
    ../../../source/common/cmsis-core/freescale/kl26z/: system_MKL26Z4.c
    ../../../source/common/hal/freescale/kl26z/: gpio.c read_uid.c uart.c usbd_MKL26Z4.c usb_config.c
    ../../../source/common/cmsis-core/freescale/kl26z/armcc/: startup_MKL26Z4.s
  group usb_core
    ../../../source/common/usb/: usbd_core.c
